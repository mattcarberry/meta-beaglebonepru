FILESEXTRAPATHS_prepend := "${THISDIR}/linux-yocto_5.0"

SRC_URI_append += "file://0001-dt-bindings-remoteproc-Add-TI-PRUSS-bindings.patch"
SRC_URI_append += "file://0002-soc-ti-pruss-Add-a-platform-driver-for-PRUSS-in-TI-S.patch"
SRC_URI_append += "file://0003-dt-binding-irqchip-Add-pruss-intc-irq-driver-for-PRU.patch"
SRC_URI_append += "file://0004-irqchip-pruss-Add-a-PRUSS-irqchip-driver-for-PRUSS-i.patch"
SRC_URI_append += "file://0005-remoteproc-add-map-parameter-to-da_to_va.patch"
SRC_URI_append += "file://0006-remoteproc-add-page-lookup-for-TI-PRU-to-ELF-loader.patch"
SRC_URI_append += "file://0007-remoteproc-Add-a-rproc_set_firmware-API.patch"
SRC_URI_append += "file://0008-remoteproc-Add-support-to-handle-device-specific-res.patch"
SRC_URI_append += "file://0009-dt-binding-remoteproc-Add-binding-doc-for-PRU-Cores-.patch"
SRC_URI_append += "file://0010-remoteproc-pru-Add-PRU-remoteproc-driver.patch"
SRC_URI_append += "file://0011-remoteproc-pru-Add-pru_rproc_set_ctable-and-pru_rpro.patch"
SRC_URI_append += "file://0012-remoteproc-pru-Add-support-for-virtio-rpmsg-stack.patch"
SRC_URI_append += "file://0013-rpmsg-virtio_rpmsg_bus-move-back-rpmsg_hdr-into-a-pu.patch"
SRC_URI_append += "file://0014-rpmsg-pru-add-a-PRU-RPMsg-driver.patch"
SRC_URI_append += "file://0015-mdio_bus-Support-more-than-one-GPIO-bus-reset-lines.patch"
SRC_URI_append += "file://0016-dt-bindings-net-Add-TI-PRUeth-bindings.patch"
SRC_URI_append += "file://0017-net-prueth-Add-TI-PRUSS-Ethernet-driver.patch"
SRC_URI_append += "file://0018-dt-binding-bus-ti-sysc-Add-support-for-PRUSS-SYSC-ty.patch"
SRC_URI_append += "file://0019-bus-ti-sysc-Add-support-for-PRUSS-SYSC-type.patch"
SRC_URI_append += "file://0020-ARM-dts-dra7-add-PRU-ICSS-modules.patch"
SRC_URI_append += "file://0021-ARM-dts-am57xx-idk-common-Enable-PRU-ICSS-nodes.patch"
SRC_URI_append += "file://0022-ARM-dts-am57xx-idk-common-Add-PRUSS2-Ethernet-applic.patch"
SRC_URI_append += "file://0023-optional-am57xx-idk-prueth-provide-intc-config-in-DT.patch"
SRC_URI_append += "file://0024-ARM-dts-AM33xx-Add-the-PRU-ICSS-DT-nodes.patch"
SRC_URI_append += "file://0025-ARM-dts-am335x-Enable-PRU-ICSS-nodes.patch"
SRC_URI_append += "file://0026-HACK-implement-reset-control-for-pruss.patch"
